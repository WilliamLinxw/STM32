# Keil uVision project ROS_serial_test_F4.uvprojx, settings and files
target ROS_serial_test_F4 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ROS_serial_test_F4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp
  c include: ..\ROSLIBS;..\USER;..\SYSTEM\USART;..\HARDWARE\DMA;..\HARDWARE\GPIO;..\HARDWARE\TIM;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HALLIB\STM32F4xx_HAL_Driver\Inc\Legacy;..\CORE\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ROSLIBS
    ../ROSLIBS/: time.cpp STM32Hardware.h
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c mainpp.cpp
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group SYSTEM
    ../SYSTEM/USART/: usart.c
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/TIM/: tim.c
  group CORE
    ../CORE/: startup_stm32f407xx.s
software components: CMSIS:CORE 3.40.0
