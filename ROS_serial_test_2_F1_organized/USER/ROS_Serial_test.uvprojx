# Keil uVision project ROS_Serial_test.uvprojx, settings and files
target ROS_Serial_test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ROS_Serial_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --cpp
  c include: ..\ROSLIBS;..\USER;..\SYSTEM\USART;..\HARDWARE\DMA;..\HARDWARE\GPIO;..\HARDWARE\TIM;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HALLIB\STM32F1xx_HAL_Driver\Inc\Legacy;..\CORE\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ROSLIBS
    ../RosLibs/: time.cpp STM32Hardware.h
  group USER
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c mainpp.cpp
  group CORE
    ../CORE/: startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c
  group SYSTEM
    ../SYSTEM/USART/: usart.c
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/TIM/: tim.c
software components: CMSIS:CORE 4.3.0
